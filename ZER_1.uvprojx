# Keil uVision project ZER_1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZER_1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c config.h utilities.c utilities.h adc_lib.c uart_lib.c adc_lib.h uart_lib.h eeprom_lib.c eeprom_lib.h rf_lib.c rf_lib.h
    ./Libs/: startup_rvmdk.S driverlib.lib
